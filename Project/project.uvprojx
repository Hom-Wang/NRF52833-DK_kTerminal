# Keil uVision project project.uvprojx, settings and files
target NRF52833DK (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52833_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x00800000,0x00020000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: NRF52833DK +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: NRF52833_XXAA, ARM_MATH_CM4, FLOAT_ABI_HARD, __TARGET_FPU_VFP, __HEAP_SIZE=8192, __STACK_SIZE=8192,KSERIAL_RECONFIG
  c include: ..\;..\Libraries;..\Libraries\integration\nrfx;..\Libraries\integration\nrfx\legacy;..\Libraries\modules\nrfx;..\Libraries\modules\nrfx\drivers\include;..\Libraries\modules\nrfx\hal;..\Libraries\modules\nrfx\mdk;..\Libraries\components;..\Libraries\components\libraries\util;..\Libraries\components\libraries\delay;..\Libraries\components\drivers_nrf\nrf_soc_nosd;..\Libraries\components\toolchain\cmsis\include;..\Libraries\components\toolchain\cmsis\dsp\Include;..\Program;..\Program\kitsprout;..\Program\segger
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x800000 size 0x20000
  group cmsis
    ../Libraries/modules/nrfx/mdk/: arm_startup_nrf52833.s system_nrf52833.c
  group drivers
    ../Program/drivers/: nrf5x_system.c nrf5x_clock.c nrf5x_delay.c nrf5x_timer.c nrf5x_uart.c
    ../Program/drivers/simui2c/: nrf5x_i2cSimu.c
  group program
    ../Program/: main.c nrf5x_bsp.c nrf5x_it.c boardConfig.h
  group modules
    ../Program/modules/: serial.c i2cmaster.c
  group kitsprout
    ../Program/kitsprout/: kLogger.c kSerial_ReConf.h
    ../Program/kitsprout/kserial/: kSerial.c kSerial.h
  group segger
    ../Program/segger/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Conf.h
